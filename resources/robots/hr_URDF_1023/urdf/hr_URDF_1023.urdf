Commit message: 20250407(1)

File: resources/robots/hr_URDF_1023/urdf/hr_URDF_1023.urdf (robot description, URDF)
Before this commit: robot hr_URDF_1023, 14 links, 13 joints
Links:
- link body: mass 10.6588 -> 2.6588
